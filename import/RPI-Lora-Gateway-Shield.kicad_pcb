# Repository hackerspace/ic880a-backplane

## KiCad design import/RPI-Lora-Gateway-Shield.kicad_pcb

Board: 2 copper layers, 99.1 x 99.1 mm, 50 parts (0 on the bottom side), 36 nets, no tracks yet.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3, @HOLE4, @HOLE5, @HOLE6, @HOLE7, @HOLE8, @HOLE9, @HOLE10: (no value)
D4: 1N4007; DO-214AC
FID2, FID3: FIDUCIAL; FIDUCIAL_1MM
FTDI: M1X6
H1, H2, H3, H4: STAND-OFF
IC880A: 1X20_LOCK
IO4, IO18, IO23, IO24: LED0805; 0805-LED
J1: GROVE; HW4-2.0
J2, J3: 1X03_LOCK
J4: RASPBERRYPI-40-PIN-GPIO; 2X20-SHROUDED
J5: DHTxx; 1X04_NO_LOCK
J6, J7: 2.54_I2C; 1X04_NO_LOCK
J8, J9, J10: CON_TERMINAL_BLOCK_02-5MM; TERMINAL_BLOCK_2P_5
J11: JUMPER_1X30805; JP3_0805
J13: GROVE I2C; HW4-2.0
J15: POWER_JACKPTH; POWER_JACK_PTH
J16: 2.54_PWR; 1X04_NO_LOCK
JP1, JP2: JUMPER2
R5: 10K; AXIAL-0.4
R6, R7, R8, R9, R10: 0805-RES
SW1: TACT_PANA-EVQ
U$1, U$9: LOGO_CH2I_110MM
U$11: OKI-78SR; OKI-78SRH

Connections:
3V3: J1.3, J4.1, J4.17, J5.1, J6.1, J7.1, J9.2, J13.3, R5.P$1, R10.2, SW1.P$2
5V-PI: J4.2, J4.4, JP1.2
+5V: J2.1, J16.4, JP1.1, JP2.2, U$11.3
GND: FTDI.1, IC880A.1, IC880A.12, IC880A.20, IO4.MINUS, IO18.MINUS, IO23.MINUS, IO24.MINUS, J1.4, J2.2, J3.1, J4.6, J4.9, J4.14, J4.20, J4.25, J4.30, J4.34, J4.39, J5.4, J6.2, J7.2, J8.2, J9.1, J13.4, J15.GND, J15.GNDBREAK, J16.1, U$11.2
GPIO4: J4.7, R6.1
GPIO13: J1.2, J4.33
GPIO18: J4.12, R8.1
GPIO19: J1.1, J4.35, SW1.P$1
GPIO23: J4.16, R7.1
GPIO24: J4.18, R9.1
GPIO26: J4.37, J5.2, R5.P$2, R10.1
GPS_PPS: IC880A.19, J4.31
GPS_RST: IC880A.3, J4.13
unnamed: D4.1, U$11.1
unnamed: IO24.PLUS, R9.2
unnamed: IO4.PLUS, R6.2
unnamed: IO23.PLUS, R7.2
unnamed: IO18.PLUS, R8.2
RXI: FTDI.4, J4.10
SCL: J4.5, J6.3, J7.3, J10.2, J13.1
SDA: J4.3, J6.4, J7.4, J10.1, J13.2
SPI_CE0: J4.24, J11.1
SPI_CE1: J4.26, J11.3
SPI_MISO: IC880A.15, J4.21
SPI_MOSI: IC880A.16, J4.19
SPI_SCLK: IC880A.14, J4.23
SPI_SS: IC880A.17, J11.2
SX_GPIO0: IC880A.7, J4.40
SX_GPIO1: IC880A.8, J4.38
SX_GPIO2: IC880A.10, J4.32
SX_GPIO3: IC880A.9, J4.36
SX_GPIO4: IC880A.11, J4.29
SX_RST: IC880A.13, J4.11
SX_SCAN: IC880A.18, J4.15
TXO: FTDI.5, J4.8
VIN: D4.2, J8.1, J15.PWR, J16.2, J16.3, JP2.1

## KiCad design backplane.kicad_pcb

Schematic: backplane.sch, iC880A RPi Backplane

Parts:
C1: C; C_1206
C2, C3: C; CP_Elec_8x10
D1: LED_Blue; LED_0805_HandSoldering
D2: LED_Yellow; LED_0805_HandSoldering
D4: D_Schottky; D_SMC
D5: D_TVS; DO-214AA; Digikey SMBJ5.0A-E3/5BGICT-ND
D6: D_TVS; D_SMC
J1: I2C; Socket_Strip_Straight_1x05_Pitch2.54mm
J2: PWR; TerminalBlock_Phoenix_PT-3.5mm_2pol
J3: Barrel_Jack; BARREL_JACK
J4: GPS_Conn; Socket_Strip_Straight_1x05_Pitch2.54mm
J5: REG_Conn; Pin_Header_Straight_1x03_Pitch2.54mm
R1: 82Ω 1/8W; R_1206
R2: 330Ω 1/8W; R_1206
R4, R5: R; R_1206
U1: Raspberry_Pi_2_3; Pin_Header_Straight_2x20_Pitch2.54mm
U2: IC880A-SPI
U3: SHT21

Connections:
3.3V: C1.2, J1.4, R4.1, R5.1, U1.1, U1.17, U3.5
5V: C3.2, J1.5, J4.1, J5.3, U1.2, U1.4, U2.21
CE0: U1.24, U2.17
CLK: U1.23, U2.14
GND: C1.1, C2.1, C3.1, D1.1, D2.1, D5.2, D6.2, J1.3, J2.1, J3.2, J3.3, J4.2, J5.2, U1.9, U1.14, U1.20, U1.25, U1.30, U1.34, U1.39, U2.1, U2.12, U2.20, U2.22, U2.24, U3.2
IC880A_RST: U1.22, U2.13
LED1: R1.1, U1.40
LED2: R2.1, U1.38
MISO: U1.21, U2.15
MOSI: U1.19, U2.16
unnamed: C2.2, D4.1, J5.1
unnamed: D1.2, R1.2
unnamed: D2.2, R2.2
PPS: J4.5, U1.12
RX: J4.3, U1.10
SCL: J1.2, R4.2, U1.5, U3.6
SDA: J1.1, R5.2, U1.3, U3.1
TX: J4.4, U1.8
VIN: D4.2, D5.1, D6.1, J2.2, J3.1

Notes on the sheet:
Raspberry Pi
iC880A
LEDs
SHT21 Sensor
I²C Breakouts
Power
The Sensirion SHT21 sensor measures both temperature and humidity. Temperature measurements are accurate to ±0.3°C, humidity is accurate to ±2%RH.
Additionally, the parts are protected against voltage spikes by a resettable fuse and a TVS diode, and against reverse polarity by a MOSFET.

Board: 2 copper layers, 80.0 x 100.0 mm, 20 parts (2 on the bottom side), 19 nets.

## Commit log

2019-01-04 modified for base48, different supply, layout
